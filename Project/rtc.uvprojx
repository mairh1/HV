# Keil uVision project rtc.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtc
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,
  c include: ..\Library\CMSIS\CM3\CoreSupport;..\Library\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Library\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\ds1302;..\User\delay;..\User\LCD1602;..\User\OLED;..\User\key
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Start
    ../Library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_ld.s
  group CMSIS
    ../Library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group STM32F10x_StdPeriph_Driver
    ../Library/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_crc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c
  group User
    ../User/: stm32f10x_conf.h stm32f10x_it.c main.c
    ../User/delay/: delay.c
    ../User/HC595/: hc595.c
    ../User/ds1302/: ds1302.c
    ../User/KEY/: key.c
